# Keil uVision project ST_boot.uvprojx, settings and files
target ST_BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stbldc_boot_s00.hex +hex
  AfterMake: D:\Program Files (x86)\Keil ARM\ARM\ARMCC\bin\fromelf.exe --bin -o  Objects/bin/ST_BOOT.bin Objects/ST_BOOT.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\Chip\STM32F0xx_StdPeriph_Driver\inc;..\boot;..\User;..\Chip\CMSIS;..\Chip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.1.1
