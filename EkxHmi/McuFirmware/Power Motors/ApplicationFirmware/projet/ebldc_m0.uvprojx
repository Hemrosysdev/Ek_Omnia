# Keil uVision project ebldc_m0.uvprojx, settings and files
target ebldc_m0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ebldc_m0_S13.hex +hex
  AfterMake: D:\Program Files (x86)\Keil ARM\ARM\ARMCC\bin\fromelf.exe --bin -o  Objects/bin/ebldc_m0.bin Objects/ebldc_m0.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\Chip;..\Chip\STM32F0xx_StdPeriph_Driver\inc;..\Chip\CMSIS;..\motor\inc;..\user;..\protocol
  memory RVCT4: ROM 0x8002000 size 0x7000
  memory RVCT9: RAM 0x200000c0 size 0x2000
software components: CMSIS:CORE 5.3.0
