///////////////////////////////////////////////////////////////////////////////
///
/// @file RadioButtonMenuItem.cpp
///
/// @brief Implementation file of class RadioButtonMenuItem
///
/// @author Ultratronik GmbH
///         Dornierstr. 9
///         D-82205 Gilching
///         Germany
///         http://www.ultratronik.de
///
/// @author written by Xaver Pilz, Forschung & Entwicklung, xpilz@ultratronik.de
///
/// @date 25.01.2021
///
/// @copyright Copyright 2021 by Hemro International AG
///            Hemro International AG
///            Länggenstrasse 34
///            CH 8184 Bachenbülach
///            Switzerland
///            Homepage: www.hemrogroup.com
///
///////////////////////////////////////////////////////////////////////////////

#include "RadioButtonMenuItem.h"

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

RadioButtonMenuItem::RadioButtonMenuItem()
{

}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

RadioButtonMenuItem::RadioButtonMenuItem( QString   value,
                                          QObject * parent )
    : QObject( parent )
    , m_value( value )
{

}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

QString RadioButtonMenuItem::key()
{
    return m_key;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void RadioButtonMenuItem::setKey( QString key )
{
    if ( m_key != key )
    {
        m_key=key;
        emit keyChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

QString RadioButtonMenuItem::value()
{
    return m_value;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void RadioButtonMenuItem::setValue( QString value )
{
    if ( m_value != value )
    {
        m_value=value;
        emit valueChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

bool RadioButtonMenuItem::isChoosable()
{
    return m_isChoosable;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void RadioButtonMenuItem::setChoosable( bool choosable )
{
    if ( m_isChoosable != choosable )
    {
        m_isChoosable=choosable;
        emit isChoosableChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

