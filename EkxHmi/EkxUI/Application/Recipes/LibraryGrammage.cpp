///////////////////////////////////////////////////////////////////////////////
///
/// @file LibraryGrammage.cpp
///
/// @brief Implementation file of class LibraryGrammage.
///
/// @author Ultratronik GmbH
///         Dornierstr. 9
///         D-82205 Gilching
///         Germany
///         http://www.ultratronik.de
///
/// @author written by Kai Uwe Broulik, kai.uwe.broulik@basyskom.com
///
/// @date 2023-02-17
///
/// @copyright Copyright 2021 by Hemro International AG
///            Hemro International AG
///            Länggenstrasse 34
///            CH 8184 Bachenbülach
///            Switzerland
///            Homepage: www.hemrogroup.com
///
///////////////////////////////////////////////////////////////////////////////

#include "LibraryGrammage.h"

#include "DddDriver.h"
#include "LibraryRecipe.h"

#include <algorithm>

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

LibraryGrammage::LibraryGrammage( bool      bPersisted,
                                  QObject * parent )
    : QObject( parent )
    , m_bPersisted( bPersisted )
{

}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

LibraryGrammage::~LibraryGrammage() = default;

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

QString LibraryGrammage::uuid() const
{
    return m_strUuid;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void LibraryGrammage::setUuid( const QString & strUuid )
{
    if ( m_strUuid != strUuid )
    {
        m_strUuid = strUuid;
        Q_EMIT uuidChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

bool LibraryGrammage::persisted() const
{
    return m_bPersisted;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void LibraryGrammage::setPersisted( bool bPersisted )
{
    if ( m_bPersisted != bPersisted )
    {
        m_bPersisted = bPersisted;
        Q_EMIT persistedChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

LibraryGrammage::Icon LibraryGrammage::icon() const
{
    return m_nIcon;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void LibraryGrammage::setIcon( LibraryGrammage::Icon nIcon )
{
    if ( m_nIcon != nIcon )
    {
        m_nIcon = nIcon;
        Q_EMIT iconChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

int LibraryGrammage::grammageMg() const
{
    return m_nGrammageMg;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void LibraryGrammage::setGrammageMg( int nGrammageMg )
{
    if ( m_nGrammageMg != nGrammageMg )
    {
        m_nGrammageMg = nGrammageMg;
        Q_EMIT grammageMgChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

int LibraryGrammage::dosingTimeMs() const
{
    return m_nDosingTimeMs;
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////

void LibraryGrammage::setDosingTimeMs( int nDosingTimeMs )
{
    if ( m_nDosingTimeMs != nDosingTimeMs )
    {
        m_nDosingTimeMs = nDosingTimeMs;
        Q_EMIT dosingTimeMsChanged();
    }
}

///////////////////////////////////////////////////////////////////////////////
//
//
///////////////////////////////////////////////////////////////////////////////
